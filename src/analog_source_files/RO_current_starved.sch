v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 30 -120 30 -90 {lab=#net1}
N 30 -30 30 10 {lab=#net2}
N 30 70 30 100 {lab=#net3}
N 30 160 30 190 {lab=GND}
N 30 -220 30 -180 {lab=VDD}
N -30 40 -10 40 {lab=RO_CLK_OUT_NC}
N -30 -60 -10 -60 {lab=RO_CLK_OUT_NC}
N -30 -60 -30 40 {lab=RO_CLK_OUT_NC}
N -60 -10 -30 -10 {lab=RO_CLK_OUT_NC}
N 30 -10 130 -10 {lab=#net2}
N 30 190 30 210 {lab=GND}
N 250 -120 250 -90 {lab=#net4}
N 250 -30 250 10 {lab=#net5}
N 250 70 250 100 {lab=#net6}
N 250 160 250 190 {lab=GND}
N 250 -220 250 -180 {lab=VDD}
N 190 40 210 40 {lab=#net2}
N 190 -60 210 -60 {lab=#net2}
N 190 -60 190 40 {lab=#net2}
N 160 -10 190 -10 {lab=#net2}
N 250 -10 350 -10 {lab=#net5}
N 250 190 250 210 {lab=GND}
N 470 -120 470 -90 {lab=#net7}
N 470 -30 470 10 {lab=#net8}
N 470 70 470 100 {lab=#net9}
N 470 160 470 190 {lab=GND}
N 470 -220 470 -180 {lab=VDD}
N 410 40 430 40 {lab=#net5}
N 410 -60 430 -60 {lab=#net5}
N 410 -60 410 40 {lab=#net5}
N 380 -10 410 -10 {lab=#net5}
N 470 -10 570 -10 {lab=#net8}
N 470 190 470 210 {lab=GND}
N 700 -120 700 -90 {lab=#net10}
N 700 -30 700 10 {lab=#net11}
N 700 70 700 100 {lab=#net12}
N 700 160 700 190 {lab=GND}
N 700 -220 700 -180 {lab=VDD}
N 640 40 660 40 {lab=#net8}
N 640 -60 660 -60 {lab=#net8}
N 640 -60 640 40 {lab=#net8}
N 610 -10 640 -10 {lab=#net8}
N 700 -10 800 -10 {lab=#net11}
N 700 190 700 210 {lab=GND}
N 930 -120 930 -90 {lab=#net13}
N 930 -30 930 10 {lab=RO_CLK_OUT_NC}
N 930 70 930 100 {lab=#net14}
N 930 160 930 190 {lab=GND}
N 930 -220 930 -180 {lab=VDD}
N 870 40 890 40 {lab=#net11}
N 870 -60 890 -60 {lab=#net11}
N 870 -60 870 40 {lab=#net11}
N 840 -10 870 -10 {lab=#net11}
N 930 190 930 210 {lab=GND}
N 130 -10 160 -10 {lab=#net2}
N 350 -10 380 -10 {lab=#net5}
N 570 -10 610 -10 {lab=#net8}
N 800 -10 840 -10 {lab=#net11}
N -170 -220 -170 -180 {lab=VDD}
N -170 -120 -170 90 {lab=#net15}
N -240 -150 -210 -150 {lab=#net16}
N -170 160 -170 190 {lab=GND}
N -170 190 -170 210 {lab=GND}
N -170 90 -170 100 {lab=#net15}
N -240 130 -210 130 {lab=#net15}
N -240 70 -240 130 {lab=#net15}
N -240 70 -170 70 {lab=#net15}
N -210 130 -10 130 {lab=#net15}
N -10 130 210 130 {lab=#net15}
N 210 130 430 130 {lab=#net15}
N 430 130 660 130 {lab=#net15}
N 660 130 890 130 {lab=#net15}
N -210 -150 -10 -150 {lab=#net16}
N -10 -150 210 -150 {lab=#net16}
N 210 -150 430 -150 {lab=#net16}
N 430 -150 660 -150 {lab=#net16}
N 660 -150 890 -150 {lab=#net16}
N 1010 -10 1010 310 {lab=RO_CLK_OUT_NC}
N -80 -10 -80 310 {lab=RO_CLK_OUT_NC}
N -80 -10 -60 -10 {lab=RO_CLK_OUT_NC}
N -360 -120 -360 40 {lab=#net16}
N -360 -220 -360 -180 {lab=VDD}
N -430 -150 -400 -150 {lab=#net16}
N -430 -150 -430 -100 {lab=#net16}
N -430 -100 -360 -100 {lab=#net16}
N -500 70 -400 70 {lab=RO_V_CONTROL}
N -400 -150 -240 -150 {lab=#net16}
N -360 100 -360 120 {lab=#net17}
N -510 70 -500 70 {lab=RO_V_CONTROL}
N -20 590 -10 590 {lab=RO_CLK_OUT}
N -510 150 -480 150 {lab=VDD}
N -510 180 -480 180 {lab=GND}
N 140 240 140 270 {lab=GND}
N 140 -10 140 180 {lab=#net2}
N 350 240 350 270 {lab=GND}
N 350 -10 350 180 {lab=#net5}
N 580 240 580 270 {lab=GND}
N 580 -10 580 180 {lab=#net8}
N 810 240 810 270 {lab=GND}
N 810 -10 810 180 {lab=#net11}
N 930 -10 1010 -10 {lab=RO_CLK_OUT_NC}
N -80 310 1010 310 {lab=RO_CLK_OUT_NC}
N -400 310 -80 310 {lab=RO_CLK_OUT_NC}
N -400 310 -400 590 {lab=RO_CLK_OUT_NC}
N -400 590 -310 590 {lab=RO_CLK_OUT_NC}
N -40 590 -20 590 {lab=RO_CLK_OUT}
N -10 590 10 590 {lab=RO_CLK_OUT}
N -60 590 -40 590 {lab=RO_CLK_OUT}
N -310 590 -270 590 {lab=RO_CLK_OUT_NC}
N -60 610 10 610 {lab=VDD}
N -60 630 10 630 {lab=GND}
N 10 630 10 640 {lab=GND}
N -390 150 -380 150 {lab=GND}
N -390 150 -390 200 {lab=GND}
N -360 180 -360 190 {lab=#net18}
N -360 250 -360 280 {lab=GND}
N -390 260 -390 270 {lab=GND}
N -390 270 -360 270 {lab=GND}
N -390 200 -390 260 {lab=GND}
N -390 220 -380 220 {lab=GND}
C {sky130_fd_pr/nfet3_01v8.sym} 10 40 0 0 {name=M1
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10 -60 0 0 {name=M2
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 10 -150 0 0 {name=M3
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 10 130 0 0 {name=M4
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 30 210 0 0 {name=l1 lab=GND}
C {lab_pin.sym} 30 -220 1 0 {name=p1 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet3_01v8.sym} 230 40 0 0 {name=M5
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 230 -60 0 0 {name=M6
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 230 -150 0 0 {name=M7
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 230 130 0 0 {name=M8
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 250 210 0 0 {name=l2 lab=GND}
C {lab_pin.sym} 250 -220 1 0 {name=p2 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet3_01v8.sym} 450 40 0 0 {name=M9
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 450 -60 0 0 {name=M10
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 450 -150 0 0 {name=M11
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 450 130 0 0 {name=M12
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 470 210 0 0 {name=l3 lab=GND}
C {lab_pin.sym} 470 -220 1 0 {name=p3 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet3_01v8.sym} 680 40 0 0 {name=M13
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 680 -60 0 0 {name=M14
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 680 -150 0 0 {name=M15
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 680 130 0 0 {name=M16
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 700 210 0 0 {name=l4 lab=GND}
C {lab_pin.sym} 700 -220 1 0 {name=p4 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet3_01v8.sym} 910 40 0 0 {name=M17
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 910 -60 0 0 {name=M18
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8.sym} 910 -150 0 0 {name=M19
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} 910 130 0 0 {name=M20
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 930 210 0 0 {name=l5 lab=GND}
C {lab_pin.sym} 930 -220 1 0 {name=p5 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/pfet3_01v8.sym} -190 -150 0 0 {name=M21
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet3_01v8.sym} -190 130 0 0 {name=M22
W=1
L=0.15
body=GND
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} -170 210 0 0 {name=l6 lab=GND}
C {sky130_fd_pr/nfet3_01v8.sym} -380 70 0 0 {name=M23
W=10
L=0.15
body=GND
nf=2
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -170 -220 1 0 {name=p6 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/pfet3_01v8.sym} -380 -150 0 0 {name=M24
W=1
L=0.15
body=VDD
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -360 -220 1 0 {name=p7 sig_type=std_logic lab=VDD}
C {gnd.sym} -360 280 0 0 {name=l7 lab=GND}
C {ipin.sym} -510 70 0 0 {name=p8 lab=RO_V_CONTROL}
C {opin.sym} 10 590 0 0 {name=p9 lab=RO_CLK_OUT}
C {iopin.sym} -510 150 2 0 {name=p10 lab=VDD}
C {iopin.sym} -510 180 2 0 {name=p11 lab=GND}
C {lab_pin.sym} -480 150 2 0 {name=p12 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -480 180 2 0 {name=p13 sig_type=std_logic lab=GND}
C {gnd.sym} 140 270 0 0 {name=l8 lab=GND}
C {gnd.sym} 350 270 0 0 {name=l9 lab=GND}
C {gnd.sym} 580 270 0 0 {name=l10 lab=GND}
C {gnd.sym} 810 270 0 0 {name=l11 lab=GND}
C {opin.sym} 1010 -10 0 0 {name=p16 lab=RO_CLK_OUT_NC}
C {output_buffer.sym} -150 610 0 0 {name=x1}
C {lab_pin.sym} 10 610 2 0 {name=p14 sig_type=std_logic lab=VDD}
C {gnd.sym} 10 640 0 0 {name=l12 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 140 210 0 0 {name=C6 model=cap_mim_m3_1 W=4 L=4 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 350 210 0 0 {name=C1 model=cap_mim_m3_1 W=4 L=4 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 580 210 0 0 {name=C2 model=cap_mim_m3_1 W=4 L=4 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 810 210 0 0 {name=C3 model=cap_mim_m3_1 W=4 L=4 MF=1 spiceprefix=X}
C {sky130_stdcells/decap_12.sym} -510 230 0 0 {name=x2 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_fd_pr/res_xhigh_po_0p35.sym} -360 150 0 0 {name=R1
L=1.1
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} -360 220 0 0 {name=R2
L=1.1
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
